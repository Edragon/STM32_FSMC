<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\HAL_STM32F103C8Tx_OLED_Example.ewp</path>
  </project>
  <batchBuild />
</workspace>
